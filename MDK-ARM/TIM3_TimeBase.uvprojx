# Keil uVision project TIM3_TimeBase.uvprojx, settings and files
target TIM3_TimeBase (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32G0001A1TC MindMotion
  pack: MindMotion.MM32G0001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TIM3_TimeBase +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\TIM3_TimeBase;..\Device\MM32G0001\Include;..\Device\MM32G0001\HAL_Lib\inc;..\Device\CMSIS\Core\Include;..\USER;..\USER\config;..\USER\power;..\USER\motor;..\USER\key;..\USER\led;..\USER\adc;..\USER\battery;..\USER\charge;..\USER\timer;..\USER\app;..\..\NX32G0001
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group APP
    ../: main.c mm32g0001_it.c platform.c
    ../USER/: user.c
    ../USER/power/: power.c
    ../USER/motor/: motor.c
    ../USER/key/: key.c
    ../USER/led/: led.c
    ../USER/adc/: adc.c
    ../USER/battery/: battery.c
    ../USER/charge/: charge.c
    ../USER/timer/: timer.c
    ../USER/app/: app.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../Device/MM32G0001/HAL_Lib/src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../Device/MM32G0001/Source/KEIL_StartAsm/: startup_mm32g0001_keil.s
    ../Device/MM32G0001/Source/: system_mm32g0001.c
